# Keil uVision project driver_gpio_test_stm32f401.uvprojx, settings and files
target Simulator (6160000::V6.16::ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: driver_gpio_test_stm32f401
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=4
  c include: ..\..\..\unity\src;..\..\..\..\include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --no_remove
  group source
    ../../../../source/driver/gpio/: driver_gpio.c
  group test
    ../../../unity/src/: unity.c
    ../: driver_gpio_test.c
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 2.6.3
