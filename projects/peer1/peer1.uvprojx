# Keil uVision project peer1.uvprojx, settings and files
target STM32F401_Master (6180000::V6.18::ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: peer1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c include: ..\..\include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../../source/application/gpio_examples/: led_chaser_sample.c
  group HAL
    ../../source/hal/gpio/: hal_gpio.c
  group Drivers
    ../../source/driver/gpio/: driver_gpio.c
    ../../source/driver/spi/: driver_spi.c
  group System
    ../../source/system/stm32f401/: system_config.c
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Device:Startup 2.6.3
